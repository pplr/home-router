inherit bundle

RAUC_BUNDLE_FORMAT = "verity"

RAUC_BUNDLE_COMPATIBLE = "futro-s920 home router"

RAUC_BUNDLE_SLOTS = "rootfs"

RAUC_SLOT_rootfs = "core-image-minimal"
