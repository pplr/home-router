COMPATIBLE_MACHINE:futro-s920 = "futro-s920"
KMACHINE:futro-s920 ?= "common-pc-64"
